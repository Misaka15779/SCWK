<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\No.2.task2.ewp</path>
  </project>
  <batchBuild />
</workspace>
